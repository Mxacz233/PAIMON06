# Keil uVision project PM06-FusionMove.uvprojx, settings and files
target PM06-FusionMove (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: PM06-FusionMove +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;./Module/AngleLock;./Module/BMI088;./Module/LineLock;./Module/M2006;./Module/PosLock;./Module/TOFSensor;./Module/Comm;./Module/MS4005
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c can.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group M2006
    ./Module/M2006/: bsp_can.c motor_control.c pid.c
  group BMI088
    ./Module/BMI088/: BMI088driver.c BMI088Middleware.c KalmanFilter.c
  group TOFSensor
    ./Module/TOFSensor/: nlink_tofsense_frame0.c nlink_tofsensem_frame0.c nlink_utils.c tofsense.c
  group AngleLock
    ./Module/AngleLock/: AngleLock.c
  group PosLock
    ./Module/PosLock/: PosLock.c
  group LineLock
    ./Module/LineLock/: liner.c
  group Comm
    ./Module/Comm/: bsp-protocol.c bsp-protocol.h
  group MS4005
    ./Module/MS4005/: lk_bsp_can.c lk_bsp_can.h MS40X.c MS40X.h
software components: CMSIS:CORE 4.3.0
